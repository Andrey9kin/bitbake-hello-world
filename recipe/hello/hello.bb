inherit prog

SRC_URI = "${FILESDIR}/src/hello.c"