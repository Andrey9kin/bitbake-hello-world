inherit prog

DEPENDS += "hello"

SRC_URI = "${FILESDIR}/src/goodbye.c"